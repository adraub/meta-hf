SUMMARY = "A pure-Python implementation of RFC 8785 (JSON Canonicalization Scheme)"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "e545841329fe0eee4f6a3b44e7034343100c12b4ec566dc06ca9735681deb4da"



